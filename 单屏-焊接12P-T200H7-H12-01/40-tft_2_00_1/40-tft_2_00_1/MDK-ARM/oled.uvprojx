# Keil uVision project oled.uvprojx, settings and files
target oled (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: oled +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: --locale=english
  c include: ..\STM32_LIB\inc;..\SYS;..\CMSIS;..\APP;..\APP\led;..\APP\OLED;..\APP\rc522;..\APP\key;..\APP\fingerprint;..\APP\lcd1602;..\APP\lcd12864;..\APP\tftlcd;..\APP\LCD
  memory RVCT4: ROM 0x8000000 size 0x50000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../APP/tftlcd/: tftlcd.c
  group CMSIS
    ../CMSIS/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_md.s
  group LIB
    ../STM32_LIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c
  group SYS
    ../SYS/: delay.c sys.c
  group User
    ./: main.c
  group Doc
    ../DOC/: readme.txt
